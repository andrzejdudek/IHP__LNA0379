** sch_path: LNA0379-main/schematic/xschem/LNA0379.sch
**.subckt LNA0379
x2 vcc! gnd! PadRing
x1 vcc! net1 net2 net3 net4 gnd! LNA0379_core
**.ends
.end
